# Keil uVision project Stepper.uvprojx, settings and files
target STM32F103C8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stepper
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  c include: ..\..\Libraries\CMSIS\CMSIS\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\System_F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Files
    ./: main.c io_uart.c dma_buffer.c stepper.c
  group STM32F10x StdPeriph Files
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group System Files
    ../../System_F10x/arm/: startup_stm32f10x_md.s
    ../../System_F10x/: system_stm32f10x.c
