# Keil uVision project W5500Test.uvprojx, settings and files
target STM32F407VGT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: W5500Test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  c include: ..\..\Libraries\CMSIS\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\System_F4xx;..\..\Libraries\ioLibrary;..\..\Libraries\ioLibrary\Ethernet
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: main.c retarget.c delay.c w5500_spi.c
  group STM32F4xx StdPeriph Files
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group System Files
    ../../System_F4xx/: system_stm32f4xx.c
    ../../System_F4xx/arm/: startup_stm32f40_41xxx.s
  group ioLibrary
    ../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../Libraries/ioLibrary/Ethernet/W5500/: w5500.c
    ../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
